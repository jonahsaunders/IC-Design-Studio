v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {res.sym} 0 0 0 0 {name=R1 value={r} m=1}
C {lab_wire.sym} 0 -30 0 0 {name=p1 lab=p}
C {lab_wire.sym} 0 30 0 0 {name=p2 lab=n}
