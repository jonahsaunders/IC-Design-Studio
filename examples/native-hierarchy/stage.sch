v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {leaf.sym} 0 0 0 0 {name=XTOP r={rtop}}
C {res.sym} 120 0 0 0 {name=RLOW value={rbottom} m=1}
C {capa.sym} 240 0 0 0 {name=CLOAD value={cload} m=1}
C {lab_wire.sym} 0 -30 0 0 {name=p1 lab=vin}
C {lab_wire.sym} 0 30 0 0 {name=p2 lab=vout}
C {lab_wire.sym} 120 -30 0 0 {name=p3 lab=vout}
C {lab_wire.sym} 120 30 0 0 {name=p4 lab=vss}
C {lab_wire.sym} 240 -30 0 0 {name=p5 lab=vout}
C {lab_wire.sym} 240 30 0 0 {name=p6 lab=vss}
